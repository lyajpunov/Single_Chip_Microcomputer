# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: main.c
    ./src/: delay.c init.c key.c lcd.c ds18b20.c moto.c model.c
